# Keil uVision project S4121.uvproj, settings and files
target AT91SAM7X512 FLASH - ULINK (ARM-ADS)
  device: AT91SAM7X512 Atmel
  cpu: IRAM(0x200000-0x21FFFF) IROM(0x100000-0x17FFFF) CLOCK(18432000) CPUTYPE(ARM7TDMI)
  output: S4121_V112_BigPeltier
  c flags: Optim=1 wLevel=2
  c include: CFG\, ..\SHARED\SRC
  asm include: .\CFG, ..\SHARED\CFG, ..\SHARED\SRC
  memory RVCT4: ROM 0x100000 size 0x80000
  memory RVCT9: RAM 0x200000 size 0x20000
  group specific device configuration
    ./CFG/: FLASH.ini RTX_Config.c AT91SAM7X.h AT91SAM7X.c sykam_cfg.c SAM7.s
  group shared device src
    ../SHARED/SRC/: lib_exceptions_funcs.c lib_exceptions_funcs.h lib_exceptions.c lib_exceptions.h common_registers_funcs.c common_registers.h common_modbus_funcs.c common_modbus_funcs.h common_modbus_tasks.c common_modbus_tasks.h common_cmds_owner.c common_cmds_owner.h common_cmds_user.c common_cmds_user.h common_cmds_reg.c common_cmds_reg.h common_support_funcs.c common_support_funcs.h common_support_tasks.c common_support_tasks.h utils_funcs.c utils_funcs.h utils_tasks.c utils_tasks.h
    C:/S4120/DEVICE/SHARED/SRC/: common_registers_funcs.h
  group application column oven
    ./SRC/: column_oven_main.c column_oven_registers_funcs.c column_oven_registers_funcs.h column_oven_registers.h column_oven_modbus_funcs.c column_oven_modbus_funcs.h column_oven_modbus_tasks.c column_oven_modbus_tasks.h column_oven_cmds_owner.c column_oven_cmds_owner.h column_oven_cmds_user.c column_oven_cmds_user.h column_oven_cmds_reg.c column_oven_cmds_reg.h column_oven_support_funcs.c column_oven_support_funcs.h column_oven_support_tasks.c column_oven_support_tasks.h column_oven_signal_processing_funcs.c column_oven_signal_processing_funcs.h column_oven_signal_processing_tasks.c column_oven_signal_processing_tasks.h column_oven_control_params.c column_oven_control_params.h
  group application valve actuator
    ./src/S6510/: valve_act_registers_funcs.c valve_act_registers_funcs.h valve_act_registers.h valve_act_modbus_funcs.c valve_act_modbus_funcs.h valve_act_modbus_tasks.c valve_act_modbus_tasks.h valve_act_cmds_owner.c valve_act_cmds_owner.h valve_act_cmds_user.c valve_act_cmds_user.h valve_act_cmds_reg.c valve_act_cmds_reg.h valve_act_support_funcs.c valve_act_support_funcs.h valve_act_support_tasks.c valve_act_support_tasks.h valve_act_valvetypes.c valve_act_valvetypes.h
  group modbus
    ../../PROTOCOL/MODBUS/: mbpb.h mbpb.c mbpbext.h mbpbdev.h mbpbdata.h mbpbcfg.h mbpbframe.h mbpbcode.h mbpbser.h mbpbser.c mbpbregcb.h mbpbregcb.c mbpbutils.h mbpbutils.c mbpbmsg.h
    ../../PROTOCOL/MODBUS/FUNCTION/: mbpbholding.h mbpbholding.c mbpbinput.h mbpbinput.c mbpbdisc.h mbpbdisc.c mbpbcoils.h mbpbcoils.c mbpbother.h mbpbother.c mbpbgeneral.c mbpbgeneral.h
  group periphery driver internal
    ../../CPU/AT91/USART/: usartdev.h usartdata.h usartext.h usart.h usart.c
    ../../CPU/AT91/PIO/: piodev.h piodata.h pioext.h pio.h pio.c
    ../../CPU/AT91/SPI/: spidev.h spidata.h spiext.h spi.h spi.c
    ../../CPU/AT91/MISC/STPCLKDIR/: stpclkdirdev.h stpclkdirdata.h stpclkdirext.h stpclkdirerr.h stpclkdir.h stpclkdir.c
    ../../CPU/AT91/MISC/STPCLKDIR/AUXILIARY/: stpclkdirauxdev.h stpclkdirauxdata.h stpclkdirauxext.h stpclkdiraux.h
    ../../CPU/AT91/PWM/: pwmdev.h pwmdata.h pwmext.h pwm.h pwm.c
    ../../CPU/AT91/RTT/: rttdev.h rttdata.h rttext.h rtt.h rtt.c
    ../../CPU/AT91/MISC/SYSIRQ/: sysirqdata.h sysirq.h sysirq.c
    ../../CPU/AT91/ADC/: adc.h adc.c adcdata.h adcdev.h adcext.h
    ../../CPU/AT91/ADCLE/: adcle.c adcle.h
  group real time library add-ons
    ../../RTL/: support.h support.c
    ../../RTL/TMR/: tmrdata.h tmr.h tmr.c
  group periphery driver external
    ../../EXT/SPI/GPIO/MCP2317/: mcp2317dev.h mcp2317data.h mcp2317ext.h mcp2317.h mcp2317.c
    ../../EXT/SPI/DAC/DACRRCS085/: dacrrcs085dev.h dacrrcs085data.h dacrrcs085ext.h dacrrcs085.h dacrrcs085.c
    ../../EXT/MISC/ENCGAPDISK/: encgapdiskdev.h encgapdiskdata.h encgapdiskdataext.h encgapdiskint.h encgapdiskext.h encgapdisk.h encgapdisk.c
    ../../EXT/SPI/NVRAM/FM25CLSS/: fm25clssdev.h fm25clssdata.h fm25clssext.h fm25clss.h fm25clss.c
  group lib driver exceptions
    C:/S4120/LIB_EXCEPTIONS_DRV/: lib_exceptions_drv.h
target AT91SAM7X512 RAM - ULINK (ARM-ADS)
  device: AT91SAM7X512 Atmel
  cpu: as above
  output: S4121
  c flags: Optim=1 wLevel=2
  c include: .\SRC
  asm define: REMAP
  memory RVCT4: ROM 0x100000 size 0x80000
  memory RVCT5: ROM 0x200000 size 0x1e078
  memory RVCT9: RAM 0x21e078 size 0x1f88
